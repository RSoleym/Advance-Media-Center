# Keil uVision project Media-Center.uvprojx, settings and files
target SWO Trace (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Media-Center
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Source Files\MP3 Files\DMA.sct
  group Source Files
    ./Source Files/: main.cpp menu.cpp photo_gallery.cpp game_center.cpp block_breaker.cpp snake_game.cpp
    ./Source Files/MP3 Files/: usbdmain.c
  group Header Files
    ./Source Files/: menu.hpp photo_gallery.hpp game_center.hpp block_breaker.hpp snake_game.hpp
  group Images
    ./Source Files/Images/: nightwing.c one_piece.c bleach.c pad.c ball.c brick.c background.c head.c body.c
  group MP3 Player
    ./Source Files/MP3 Files/: adcuser.c core_cm3.c usbuser.c usbcore.c usbdesc.c usbhw.c adcuser.h audio.h core_cm3.h LPC17xx.h type.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbdmain.h usbhw.h usbreg.h usbuser.h
  group Board Files
    ./Source Files/MP3 Files/: startup_LPC17xx.s system_LPC17xx.c
    ./Source Files/Board Files/: Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c KBD.c KBD.h LED.c LED.h
target TracePort Trace (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TRACE_PIN_ENABLE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Instruction Trace (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TRACE_PIN_ENABLE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:A/D Converter 1.0.0, Device:PIN 1.0.0
